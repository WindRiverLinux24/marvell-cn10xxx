COMPATIBLE_MACHINE:marvell-cn10xxx = "marvell-cn10xxx"
