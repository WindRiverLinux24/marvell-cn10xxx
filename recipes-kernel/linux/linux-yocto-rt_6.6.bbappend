require linux-yocto-marvell-cn10xxx.inc

KBRANCH:marvell-cn10xxx = "v6.6/standard/preempt-rt/cn-sdkv6.1/octeon"
