KBRANCH_marvell-cn106xx  = "v5.10/standard/cn-sdkv5.4/octeon"

require linux-yocto-marvell-cn106xx.inc

LINUX_VERSION_marvell-cn106xx ?= "5.10.x"
