PACKAGECONFIG[blkid] = "-Dblkid=true,-Dblkid=false"
PACKAGECONFIG_append = " blkid"
PACKAGECONFIG_remove_marvell-cn106xx = "blkid"
